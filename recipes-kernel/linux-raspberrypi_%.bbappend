do_configure_prepend_raspberrypi3() {
    kernel_configure_variable VIDEO_BCM2835_MMAL y
}


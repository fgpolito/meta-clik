# Base this image on core-image-minimal and qemu-arm support 
include recipes-core/images/core-image-minimal.bb

require common.inc

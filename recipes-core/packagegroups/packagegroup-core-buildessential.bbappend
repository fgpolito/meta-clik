RDEPENDS_packagegroup-core-buildessential += "\
	gfortran \
	gfortran-symlinks \
	"

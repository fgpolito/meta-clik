RDEPENDS_${PN} += "\
	libgfortran \
	libgfortran-dev \
	"

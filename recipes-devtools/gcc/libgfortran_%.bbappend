# enable fortran in libgfortran
FORTRAN = ",fortran"

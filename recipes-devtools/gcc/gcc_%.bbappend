# enable fortran in gcc
FORTRAN = ",fortran"

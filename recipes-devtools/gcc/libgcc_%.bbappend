# enable fortran in libgcc
#FORTRAN = ",fortran"

# enable fortran in gcc-runtime
#FORTRAN = ",fortran"

#RUNTIMETARGET += "libgfortran"

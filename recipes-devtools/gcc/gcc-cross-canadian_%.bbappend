# enable fortran in gcc-cross-canadian
FORTRAN = ",fortran"

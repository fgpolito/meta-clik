# enable fortran in gcc-cross
FORTRAN = ",fortran"

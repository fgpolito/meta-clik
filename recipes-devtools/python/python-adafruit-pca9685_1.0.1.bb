inherit setuptools
require python-adafruit-pca9685.inc

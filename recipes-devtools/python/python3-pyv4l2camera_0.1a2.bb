inherit setuptools3
require python-pyv4l2camera.inc

inherit setuptools3
require python-python-vlc.inc

inherit setuptools3
require python-adafruit-gpio.inc

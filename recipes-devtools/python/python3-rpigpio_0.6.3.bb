inherit setuptools3
require python-rpigpio.inc

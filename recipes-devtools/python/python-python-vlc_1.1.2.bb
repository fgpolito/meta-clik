inherit setuptools
require python-python-vlc.inc

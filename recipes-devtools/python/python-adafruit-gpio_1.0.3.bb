inherit setuptools
require python-adafruit-gpio.inc

inherit setuptools3
require python-cognitive-face.inc

inherit setuptools3
require python-adafruit-pca9685.inc

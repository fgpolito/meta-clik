inherit setuptools
require python-adaptfilt.inc

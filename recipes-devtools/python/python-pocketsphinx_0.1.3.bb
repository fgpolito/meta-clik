require python-pocketsphinx.inc
inherit setuptools

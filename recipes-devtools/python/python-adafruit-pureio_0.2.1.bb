inherit setuptools
require python-adafruit-pureio.inc

inherit setuptools
require python-rpigpio.inc

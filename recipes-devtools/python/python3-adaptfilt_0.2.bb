inherit setuptools3
require python-adaptfilt.inc

SRC_URI += "file://0001-Make-adaptfilt-compatible-with-python3.patch"

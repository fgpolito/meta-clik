inherit setuptools3
require python-adafruit-pureio.inc
